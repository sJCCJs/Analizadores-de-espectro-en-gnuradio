options:
  parameters:
    generate_options: qt_gui
    id: AnalizadorUltrasonidos
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: hw:0,0
    samp_rate: samp_rate
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    name: AnalizadorSonidos
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [audio_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
