options:
  parameters:
    generate_options: qt_gui
    id: AnalizadorEspectro
    output_language: python
    title: Analizador de espectro FM
  states: {}

blocks:
- name: GananciaRF
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '50'
    value: '20'
  states: {}
- name: SintonizadorFM
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 88e6
    step: 1e5
    stop: 108e6
    value: 96.6e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1400000'
  states: {}
- name: import_0
  id: import
  parameters: {}
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: rtl=0
    bb_gain0: GananciaRF
    freq0: SintonizadorFM
    gain0: GananciaRF
    gain_mode0: 'True'
    if_gain0: GananciaRF
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: SintonizadorFM
    fftsize: '2048'
    grid: 'True'
    name: EspectroFM
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
